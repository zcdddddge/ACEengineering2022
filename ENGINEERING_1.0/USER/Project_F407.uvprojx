# Keil uVision project Project_F407.uvprojx, settings and files
target infantry_chassis (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry_chassis +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\LIBRARIES\startup;.\Listings;..\LIBRARIES\dsp_lib\Include;..\LIBRARIES\device;..\application;..\application\chassis;..\application\gimbal;..\boards;..\control;..\delay;..\operation;..\operation\list_of_function;..\referee;..\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../LIBRARIES/startup/: startup_stm32f40_41xxx.s
    ../LIBRARIES/dsp_lib/: arm_cortexM4lf_math.lib
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../LIBRARIES/device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group delay
    ../delay/: delay.c
  group boards
    ../boards/: can.c iwdg.c key.c led.c photoelectric.c pwm.c time.c usart1.c usart6.c usart2.c usart3.c uart4.c
  group control
    ../control/: can_1_receive.c can_2_receive.c capacitor_control.c imu.c rc.c upper_machine.c visual.c gpio_deal.c vl53l0.c
  group referee
    ../referee/: crc.c referee_deal.c rm_cilent_ui.c ui_task.c
  group application
    ../application/: calibrate_task.c detect_task.c init.c security_task.c shoot_task.c system_state.c struct_typedef.h parameter.h
  group chassis_app
    ../application/chassis/: chassis_app.c chassis_behaviour.c chassis_task.c
  group gimbal_app
    ../application/gimbal/: gimbal_app.c gimbal_behaviour.c gimbal_task.c
  group operation
    ../operation/: fifo_buff.c filter.c maths.c pid.c rm_motor.c
    ../operation/list_of_function/: list_of_function.h
  group timer
    ../timer/: timer_task.c
