# Keil uVision project engineering.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ENGINEERING2020 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,A_BOARD,TextMode,RcMode,ContextMode
  c include: ..\FWLIB\inc;..\CMSIS;..\USER;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\include;..\USER\HeaderFile\Hardware;..\USER\HeaderFile\Drive;..\USER\HeaderFile\INIT;..\USER\HeaderFile\Functional;..\USER\HeaderFile\Task;..\USER\HeaderFile\Lib;..\USER\REFEREE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c delay.c
    ../USER/SourceFile/INIT/: HardwareInit.c TaskInit.c
  group STARTUP
    ../STARTUP/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c timers.c list.c tasks.c queue.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Hareward
    ../USER/SourceFile/Hardware/: CAN.c GPIO.c TIM.c USART.c IWDG.c
  group Drive
    ../USER/SourceFile/Drive/: CAN1_ISR.c CAN2_ISR.c encoder.c GPIO_DEAL.c GYRO_ISR.c REMOTE_ISR.c TIM_ISR.c VISION_ISR.c PYR_ISR.c REFEREE_ISR.c crc.c
  group Funtional
    ../USER/SourceFile/Functional/: BoardCommuni.c ChassisMotor.c GimbalMotor.c motor.c pid.c RemoteDeal.c UserReferee.c
  group Task
    ../USER/SourceFile/Task/: Chassis_Task.c Chassis_Fsm.c Communi_Task.c Detect_Task.c Gimbal_Task.c Remote_Task.c fsm.c
  group Lib
    ../USER/SourceFile/Lib/: FilterLib.c MathLib.c Triangles.c
    ../USER/HeaderFile/Lib/: math.h
